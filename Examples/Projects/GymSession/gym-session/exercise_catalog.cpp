#include "exercise_catalog.h"

namespace {

const uint32_t pushLow[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFCFFFFF, 0xF1023FFF,
  0xE000003F, 0xF100003F, 0xFFCFFFBF, 0x00000000
};

const uint32_t pushHigh[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xF18FFFFF, 0xE0063FFF, 0xF1001FFF, 0xFF8003FF,
  0xFF9FF03F, 0xFF9FFE3F, 0xFF9FFFBF, 0x00000000
};


const Animation32 push = {
  {{pushLow, sizeof(pushLow) / sizeof(pushLow[0])},
   {pushHigh, sizeof(pushHigh) / sizeof(pushHigh[0])}},
  2, 400
};

const uint32_t pressUp[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFCFFFFF, 0xF387FFFF, 0xE103FFFF, 0xE0021FFF,
  0xE10001FF, 0xF3801DFF, 0xC00005FF, 0xC00005FF,
  0xFFFFFDFF, 0xFFFFFDFF, 0xFFFFFDFF, 0xFFFFFC7F,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};

const uint32_t pressDown[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFCFFFFF, 0xFF87FFFF, 0xFF87FFFF, 0xFFCFFFFF,
  0xFFEFFFFF, 0xF3EFFFFF, 0xE103FFFF, 0xE0021FFF,
  0xE10001FF, 0xF3801DFF, 0xC00005FF, 0xC00005FF,
  0xFFFFFDFF, 0xFFFFFDFF, 0xFFFFFDFF, 0xFFFFFC7F,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};

const uint32_t pressWide[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFCFFFFF, 0xFF87FFFF, 0xFF87FFFF,
  0xFFCFFFFF, 0xFFEFFFFF, 0xFFEFFFFF, 0xFFEFFFFF,
  0xFFEFFFFF, 0xF3EFFFFF, 0xE103FFFF, 0xE0021FFF,
  0xE10001FF, 0xF3801DFF, 0xC00005FF, 0xC00005FF,
  0xFFFFFDFF, 0xFFFFFDFF, 0xFFFFFDFF, 0xFFFFFC7F,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};

const Animation32 press = {{{pressUp, sizeof(pressUp) / sizeof(pressUp[0])}, {pressDown, sizeof(pressDown) / sizeof(pressDown[0])}, {pressWide, sizeof(pressWide) / sizeof(pressWide[0])}}, 3, 400};

const uint32_t crunchOpen[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFF1FF, 0xFFFFE0FF, 0xFFFFC0FF,
  0xFF0F847F, 0xC40F0E7F, 0x80C60E3F, 0x80001F3F,
  0x80001F3F, 0x82003F1F, 0xC7007F0F, 0x00000000
};

const uint32_t crunchClosed[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFE3FFFFF,
  0xFC0FFFFF, 0xFC03FFFF, 0xFC10FFFF, 0xFC18FFFF,
  0xFE39FFFF, 0xFF33F1FF, 0xFF03E0FF, 0xFF87C0FF,
  0xFF83847F, 0xFFC0867F, 0xFFE00E3F, 0xFFE00F3F,
  0xFFF01F3F, 0xFFF83F1F, 0xFFFC7F0F, 0x00000000
};

const Animation32 crunch = {
  {{crunchOpen, sizeof(crunchOpen) / sizeof(crunchOpen[0])}, {crunchClosed, sizeof(crunchClosed) / sizeof(crunchClosed[0])}},
  2, 400
};

const uint32_t pullHigh[32] = {
  0xFFFFFFFF, 0x9FFFFFF9, 0x9FFFFFF9, 0x9C7C7E39,
  0x80000001, 0x9EF83F79, 0x9E7C7F79, 0x9F400679,
  0x9F4006F9, 0x9F1830F9, 0x9F3839F9, 0x9FFC7FF9,
  0x9FFC7FF9, 0x9FF83FF9, 0x9FF83FF9, 0x9FF93FF9,
  0x9FF11FF9, 0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9,
  0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9,
  0x9FFFFFF9, 0x9FFFFFF9, 0x9FFFFFF9, 0x9FFFFFF9,
  0x9FFFFFF9, 0x9FFFFFF9, 0x9FFFFFF9, 0x00000000
};

const uint32_t pullLow[32] = {
  0xFFFFFFFF, 0x9FFFFFF9, 0x9FFFFFF9, 0x9C7FFE39,
  0x80000001, 0x9EFFFF79, 0x9E7FFE79, 0x9F3FFEF9,
  0x9FBFFDF9, 0x9F9C79F9, 0x9FD833F9, 0x9FE827F9,
  0x9FE44FF9, 0x9FF01FF9, 0x9FF83FF9, 0x9FF83FF9,
  0x9FF83FF9, 0x9FFC7FF9, 0x9FFC7FF9, 0x9FF83FF9,
  0x9FF83FF9, 0x9FF93FF9, 0x9FF11FF9, 0x9FF39FF9,
  0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9,
  0x9FF39FF9, 0x9FF39FF9, 0x9FFFFFF9, 0x00000000
};

const uint32_t pullMed[32] = {
  0xFFFFFFFF, 0x9FFFFFF9, 0x9FFFFFF9, 0x9C7FFE39,
  0x80000001, 0x9EFFFF79, 0x9E7C7E79, 0x9F783CF9,
  0x9FB83DF9, 0x9F9C79F9, 0x9FC003F9, 0x9FC007F9,
  0x9FF83FF9, 0x9FF83FF9, 0x9FFC7FF9, 0x9FFC7FF9,
  0x9FF83FF9, 0x9FF83FF9, 0x9FF93FF9, 0x9FF11FF9,
  0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9,
  0x9FF39FF9, 0x9FF39FF9, 0x9FF39FF9, 0x9FFFFFF9,
  0x9FFFFFF9, 0x9FFFFFF9, 0x9FFFFFF9, 0x00000000
};

const Animation32 pull = {
  {{pullLow, sizeof(pullLow) / sizeof(pullLow[0])}, {pullMed, sizeof(pullMed) / sizeof(pullMed[0])}, {pullHigh, sizeof(pullHigh) / sizeof(pullHigh[0])}},
  3, 400
};

const uint32_t squatUp[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFE3FFF, 0xFFFC1FFF, 0xFFFC1FFF,
  0xFFFC1FFF, 0xFFFE3FFF, 0xFFFF3FFF, 0xFFFF3FFF,
  0xFFFE1FFF, 0xFFF807FF, 0xFFE001FF, 0xFF83307F,
  0xFF8F3C7F, 0xFFFF3FFF, 0xFFFF3FFF, 0xFFFF1FFF,
  0xFFFE1FFF, 0xFFFC0FFF, 0xFFFCCFFF, 0xFFFCC7FF,
  0xFFF8E3FF, 0xFFF1F3FF, 0xFFF3F1FF, 0xFF83F07F,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};
const uint32_t squatDown[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFE3FFF, 0xFFFC1FFF, 0xFFFC1FFF,
  0xFFFC1FFF, 0xFFFE3FFF, 0xFFFF3FFF, 0xFFFF3FFF,
  0xFFFE1FFF, 0xFFE001FF, 0xFF80007F, 0xFF8F3C7F,
  0xFFFF3FFF, 0xFFFC0FFF, 0xFFF003FF, 0xFFE1E1FF,
  0xFFC7F8FF, 0xFFCFFCFF, 0xFFCFFCFF, 0xFF8FFC7F,
  0xFE0FF83F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};
const Animation32 squat = {{{squatUp, sizeof(squatUp) / sizeof(squatUp[0])}, {squatDown, sizeof(squatDown) / sizeof(squatDown[0])}}, 2, 500};

const uint32_t restPose[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFE3FFF, 0xFFFC1FFF, 0xFFFC1FFF,
  0xFFFC1FFF, 0xFFFE3FFF, 0xFFFF3FFF, 0xFFFF3FFF,
  0xFFFF3FFF, 0xFFFE1FFF, 0xFFF807FF, 0xFFF003FF,
  0xFFE331FF, 0xFFE739FF, 0xFFFF3FFF, 0xFFFF3FFF,
  0xFFFF3FFF, 0xFFFE1FFF, 0xFFFE0FFF, 0xFFFC4FFF,
  0xFFFCCFFF, 0xFFFCC7FF, 0xFFF8E3FF, 0xFFF9F3FF,
  0xFFE0E0FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};
const uint32_t restPoseShifted[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFC7FFF, 0xFFF83FFF, 0xFFF83FFF,
  0xFFF83FFF, 0xFFFC7FFF, 0xFFFE7FFF, 0xFFFE7FFF,
  0xFFFE7FFF, 0xFFF83FFF, 0xFFE00FFF, 0xFFC207FF,
  0xFFCE63FF, 0xFFFE73FF, 0xFFFE7FFF, 0xFFFE7FFF,
  0xFFFE3FFF, 0xFFFC3FFF, 0xFFFC1FFF, 0xFFFC9FFF,
  0xFFF88FFF, 0xFFF9C7FF, 0xFFF1E1FF, 0xFFF3F0FF,
  0xFFC1F83F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF
};
const Animation32 rest = {{{restPose, sizeof(restPose) / sizeof(restPose[0])}, {restPoseShifted, sizeof(restPoseShifted) / sizeof(restPoseShifted[0])}}, 2, 600};

const uint32_t plankDown[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xF107FFFF, 0xE0007FFF,
  0xE100007F, 0xFF9F003F, 0xFE1FFFBF, 0x00000000
};

const uint32_t plankUp[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xF10FFFFF, 0xE0003FFF,
  0xF100007F, 0xFF9F003F, 0xFE3FFFBF, 0x00000000
};

const Animation32 plank = {{{plankUp, sizeof(plankUp) / sizeof(plankUp[0])}, {plankDown, sizeof(plankDown) / sizeof(plankDown[0])}}, 2, 500};

const uint32_t jumpingJacksDown[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFC7FFF, 0xFFF83FFF, 0xFFF83FFF, 0xFFFC7FFF,
  0xFFFEFFFF, 0xFFF01FFF, 0xFFF01FFF, 0xFFE01FFF,
  0xFFE80FFF, 0xFFEC6FFF, 0xFFCC6FFF, 0xFFD827FF,
  0xFFD837FF, 0xFF9837FF, 0xFFB83BFF, 0xFFF93FFF,
  0xFFF93FFF, 0xFFF93FFF, 0xFFF93FFF, 0xFFF93FFF,
  0xFFF93FFF, 0xFFF93FFF, 0xFFF11FFF, 0x00000000
};

const uint32_t jumpingJacksMed[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFC7FFF, 0xFFF83FFF, 0xFFF83FFF, 0xFFFC7FFF,
  0xFFFEFFFF, 0xFFE00FFF, 0xFE00007F, 0xFC783F3F,
  0xFFF83FFF, 0xFFFC7FFF, 0xFFFC7FFF, 0xFFF83FFF,
  0xFFF83FFF, 0xFFF01FFF, 0xFFF39FFF, 0xFFE38FFF,
  0xFFE7CFFF, 0xFFE7CFFF, 0xFFCFE7FF, 0xFFCFE7FF,
  0xFFCFE7FF, 0xFF9FF3FF, 0xFFFFFFFF, 0x00000000
};

const uint32_t jumpingJacksUp[32] = {
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
  0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF7C7EFF,
  0xFF383CFF, 0xFF9839FF, 0xFFCC7BFF, 0xFFEEF3FF,
  0xFFE027FF, 0xFFF00FFF, 0xFFF01FFF, 0xFFF83FFF,
  0xFFFC7FFF, 0xFFFC7FFF, 0xFFFC3FFF, 0xFFF83FFF,
  0xFFF81FFF, 0xFFF99FFF, 0xFFF38FFF, 0xFFF3CFFF,
  0xFFE7C7FF, 0xFFE7E7FF, 0xFFC7F3FF, 0xFFCFF3FF,
  0xFF1FF1FF, 0xFFFFFFFF, 0xFFFFFFFF, 0x00000000
};

const Animation32 jumpingJacks = {
  {{jumpingJacksDown, sizeof(jumpingJacksDown) / sizeof(jumpingJacksDown[0])}, {jumpingJacksMed, sizeof(jumpingJacksMed) / sizeof(jumpingJacksMed[0])}, {jumpingJacksUp, sizeof(jumpingJacksUp) / sizeof(jumpingJacksUp[0])}},
  3, 200
};

const ExerciseDef catalog[] = {
  {"Bench press", REPS, PARAM_REPS | PARAM_WEIGHT, 6, 10, 20, &press},
  {"Abdominal crunch", REPS, PARAM_REPS, 5, 12, 0, &crunch},
  {"Pull-up", REPS, PARAM_REPS, 8, 8, 0, &pull},
  {"Push-up", REPS, PARAM_REPS, 8, 10, 0, &push},
  {"Plank", TIME, PARAM_TIME, 4, 30, 0, &plank},
  {"Bodyweight squat", REPS, PARAM_REPS, 6, 12, 0, &squat},
  {"Jumping jacks", TIME, PARAM_TIME, 8, 30, 0, &jumpingJacks}
};
}

const Animation32 REST_ANIMATION = rest;

const ExerciseDef exercises[] = {
  catalog[0], catalog[1], catalog[2], catalog[3], catalog[4], catalog[5], catalog[6]
};
const uint8_t EXERCISE_COUNT = sizeof(exercises) / sizeof(exercises[0]);

uint8_t exerciseDefaultValue(uint8_t exerciseId) {
  return exerciseId < EXERCISE_COUNT ? exercises[exerciseId].defaultValue : 1;
}

uint8_t exerciseDefaultWeight(uint8_t exerciseId) {
  return exerciseId < EXERCISE_COUNT ? exercises[exerciseId].defaultWeight : 0;
}

bool exerciseHasWeight(uint8_t exerciseId) {
  return exerciseId < EXERCISE_COUNT && (exercises[exerciseId].parameters & PARAM_WEIGHT);
}

void drawExerciseAnimation(TFT_eSprite &sprite, const Animation32 &animation, uint8_t frame) {
  if (!animation.frameCount || animation.frameCount > 3) return;
  for (uint8_t index = 0; index < animation.frameCount; index++) {
    if (!animation.frames[index].rows || animation.frames[index].rowCount != 32) return;
  }
  const uint32_t *bitmap = animation.frames[frame % animation.frameCount].rows;
  const uint8_t scale = min(sprite.width() / 32, sprite.height() / 32);
  const int16_t left = (sprite.width() - 32 * scale) / 2;
  const int16_t top = (sprite.height() - 32 * scale) / 2;
  for (uint8_t y = 0; y < 32; y++) {
    uint32_t row = bitmap[y];
    for (uint8_t x = 0; x < 32; x++) {
      if (row & (0x80000000UL >> x)) {
        sprite.fillRect(left + x * scale, top + y * scale, scale, scale, TFT_WHITE);
      }
    }
  }
}
